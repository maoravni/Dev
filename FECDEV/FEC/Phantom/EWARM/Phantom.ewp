# IAR project Phantom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\SW\CNFG
  OBJCOPY.OOCOutputFile: Phantom.srec
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APPLIC
    ../SW/APPLIC/SRC/: CmbrCfgDB.c GnrlCfgDB.c Monitor.c PWM.c
    ../SW/APPLIC/INC/: CmbrCfgDB.h GnrlCfgDB.h Phantom.h
    ../../Common/GEN_INC/: ll_typedef.h
  group AUX_TERM
    ../../Common/AUX_TERM/: aux_term.c aux_term.h
  group BSP
    ../../Common/Libraries/BSP/: board_setup.c bsp_srvcs.h eeprom_mc24xx1025.c eeprom_mc24xx1025.h iwdg.c iwdg.h rtc.c rtc.h
    ../SW/CNFG/: board_setup.h
    ../SW/BSP/: netconf.c stm32f2x7_eth_bsp.c tcpecho.c usart_ph.c
  group CMSIS
    ../SW/CMSIS/: stm32f2xx_it.c system_stm32f2xx.c
  group CNFG
    ../SW/CNFG/: aux_trm_cnfg.h cfg_db_if_cnfg.h cpal_conf.h eeprom_cnfg.h FreeRTOSConfig.h iwdg_cnfg.h leds_cnfg.h lwipopts.h main.h mb_cnfg.h os_cnfg.h stm32f2xx_conf.h
  group DB
    ../../Common/DB/SRC/: cfg_db_eeprom.c cfg_db_if.c CfgDB.c CfgDButil.c
    ../../Common/DB/INC/: cfg_db_eeprom.h cfg_db_if.h CfgDB.h CfgDBUtil.h
  group EWARM
    ./: startup_stm32f2xx.s
  group FreeRTOS
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/: croutine.c list.c queue.c tasks.c
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/include/: free_rtos_exp.h
  group FreeRTOS/portable
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/portable/MemMang/: heap_2.c
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/portable/EWARM/ARM_CM3/: port.c portasm.s
  group HMI
    ../../Common/HMI/: leds.c leds.h
  group LWIP/API
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/CORE
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LWIP/CORE/IPv4
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP/NETIF
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group MODBUS/COMMON
    ../../Common/MODBUS/Common/: mb_infra.c mb_infra.h
  group MODBUS/RTU
    ../../Common/MODBUS/Rtu/: rtu_master.c rtu_master.h rtu_msgs.h rtu_slave.c rtu_slave.h
  group MODBUS/TCP_MB
    ../../Common/MODBUS/MbTcp/: tcp_mb.c tcp_mb.h
  group STM32F2x7_ETH_Driver
    ../../Common/Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group TEST
    ../SW/TEST/: main.c
  group Trace
    ../../Common/DebugTrace/: LogSys.c
  group USB/STM32_USB_Device_Library/Class/cdc
    ../../Common/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../../Common/USB/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h usbd_cdc_if_template.h
  group USB/STM32_USB_Device_Library/Core
    ../../Common/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Common/USB/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USB/STM32_USB_OTG_Driver
    ../../Common/USB/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
    ../../Common/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group VCP_TERM
    ../../Common/USB/VCP/src/: data.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ../../Common/VCP_TERM/: vcp_term.c vcp_term.h
