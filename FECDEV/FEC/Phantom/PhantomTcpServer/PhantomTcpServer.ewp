# IAR project PhantomTcpServer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_HS; USE_EMBEDDED_PHY; PHANTOM_BOARD; CPP_FRAMEWORK; _NEW_IBD_CONTROL_
  ICCARM.CCIncludePath2: ..\SW\CNFG; ..\SW\TmcServer; $PROJ_DIR$..\..\..\Common\TmcServer; $PROJ_DIR$..\..\..\Common; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\BSP\EEPROM; $PROJ_DIR$..\..\..\Common\Libraries\STM32_CPAL_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\GEN_INC; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\inc; //$PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; //..\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\HMI; $PROJ_DIR$..\..\..\Phantom\SW\APPLIC\INC; $PROJ_DIR$..\..\..\Common\DB\INC; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\USB\VCP\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Class\cdc\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Core\inc; $PROJ_DIR$..\..\..\Common\VCP_TERM; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOS_EC\Source\; $PROJ_DIR$..\..\..\Common\CppFramework; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\include\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\portable\IAR\ARM_CM3; $PROJ_DIR$..\..\..\Common\MODBUS; $PROJ_DIR$..\..\..\Common\MODBUS\rtu; $PROJ_DIR$..\..\..\Common\AUX_TERM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\SW\CNFG
  OBJCOPY.OOCOutputFile: PhantomTcpServer.srec
  ILINK.IlinkOutputFile: PhantomTcpServer.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
configuration Debug_NEW_IBD_CONTROL_ (ARM, debug)
  as the first configuration, except:
  group APPLIC
    ../SW/APPLIC/SRC/: GnrlCfgDB.c Monitor.c OthersCfgDB.c PWM.c TemperatureCfgDB.c
    ../SW/APPLIC/INC/: GnrlCfgDB.h Monitor.h OthersCfgDB.h Phantom.h TemperatureCfgDB.h
    ../../Common/GEN_INC/: ll_typedef.h
  group AUX_TERM
    ../../Common/AUX_TERM/: aux_term.c aux_term.h
  group BSP
    ../../Common/Libraries/BSP/: board_setup.c bsp_srvcs.h eeprom_mc24xx1025.c eeprom_mc24xx1025.h iwdg.c iwdg.h netconf.c opto_out.c opto_out.h rtc.c rtc.h
    ../SW/CNFG/: board_setup.h
    ../SW/BSP/: stm32f2x7_eth_bsp.c tcpecho.c usart_ph.c
  group CFreeRTOS
    ../../Common/3rdParty/FreeRTOS_EC/Source/: AManagedTask.cpp AManagedTask.h ASyncObject.cpp ASyncObject.h ATimer.cpp ATimer.h CBinarySemaphore.cpp CBinarySemaphore.h CCountingSemaphore.cpp CCountingSemaphore.h CFreeRTOS.cpp CFreeRTOS.h CMessageTask.cpp CMessageTask.h CMutex.cpp CMutex.h CQueue.cpp CQueue.h CRecursiveMutex.cpp CRecursiveMutex.h CSharedResource.h CTask.cpp CTask.h IFreeRTOSProtocol.h IMessageTaskDelegate.h Message.h MessageMacro.h
  group CMSIS
    ../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../SW/CMSIS_FreeRTOS_7/: stm32f2xx_it.c
    ../SW/CMSIS/: system_stm32f2xx.c
  group CNFG
    ../SW/CNFG/: aux_trm_cnfg.h cfg_db_if_cnfg.h cpal_conf.h FreeRTOSConfig.h iwdg_cnfg.h leds_cnfg.h lwipopts.h main.h mb_cnfg.h opto_out_cnfg.h os_cnfg.h stm32f2xx_conf.h
    ../../Common/: version.h
  group CppFramework
    ../../Common/CppFramework/: AirBleedingZone.cpp AirBleedingZone.h AirBlowerZone.cpp AirBlowerZone.h BaseMiddlewareWrapperZone.cpp BaseMiddlewareWrapperZone.h BaseZone.cpp BaseZone.h CBaseConnector.cpp CBaseConnector.h CLogger.cpp CLogger.h CTcpConnector.cpp CTcpConnector.h EventData.cpp EventData.h HeaterZone.cpp HeaterZone.h HumidityZone.cpp HumidityZone.h IbdZone.cpp IbdZone.h logger.h MiddlewareRegisterMonitor.cpp MiddlewareRegisterMonitor.h operatorNew.cpp PeriodicMonitorTask.cpp PeriodicMonitorTask.h StateMachine.cpp StateMachine.h StatusLed.cpp StatusLed.h TemperatureZone.cpp TemperatureZone.h ZoneManager.cpp ZoneManager.h
  group DB
    ../../Common/DB/SRC/: cfg_db_eeprom.c cfg_db_if.c CfgDB.c CfgDButil.c
    ../../Common/DB/INC/: cfg_db_eeprom.h cfg_db_if.h CfgDB.h CfgDBUtil.h
  group FreeRTOS
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/include
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/memmang
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c
  group FreeRTOS/portable
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group HMI
    ../../Common/HMI/: leds.c leds.h
  group LWIP/API
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/CORE
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LWIP/CORE/IPv4
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP/NETIF
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group MODBUS
    ../../Common/MODBUS/: modbus_exp.h
  group MODBUS/COMMON
    ../../Common/MODBUS/Common/: mb_infra.c mb_infra.h
  group MODBUS/RTU
    ../../Common/MODBUS/Rtu/: rtu_master.c rtu_master.h rtu_msgs.h rtu_slave.c rtu_slave.h
  group MODBUS/TCP_MB
    ../../Common/MODBUS/MbTcp/: tcp_mb.c tcp_mb.h
  group STM32F2x7_ETH_Driver
    ../../Common/Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group TEST
    ../SW/MAIN/: Main.cpp
  group TmcServerCommon
    ../../Common/TmcServer/: GeneratedMessages.def.h GeneratedMessages.msg.h PhantomIbdZones.cpp PhantomIbdZones.h PhantomZones.cpp PhantomZones.h TmcMasterServer.cpp TmcMasterServer.h TmcMessageHandler.cpp TmcMessageHandler.h TmcStateMachine.cpp TmcStateMachine.h
  group Trace
    ../../Common/DebugTrace/: LogSys.c
  group USB/STM32_USB_Device_Library/Class/cdc
    ../../Common/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../../Common/USB/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h usbd_cdc_if_template.h
  group USB/STM32_USB_Device_Library/Core
    ../../Common/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Common/USB/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USB/STM32_USB_OTG_Driver
    ../../Common/USB/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
    ../../Common/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group VCP_TERM
    ../../Common/USB/VCP/src/: data.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ../../Common/VCP_TERM/: vcp_term.c vcp_term.h
