# IAR project FEC2_PSoC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CY8C5868AXI-LP032 Cypress CY8C5868AXI-LP032
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: -DCyTemp
  ICCARM.CCIncludePath2: .; Generated_Source\PSoC5; ..\FEC2_PSoC_Common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: .; Generated_Source\PSoC5
  postbuild: ".\Export\postbuild.bat" "$TARGET_PATH$" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: FEC2_PSoC.out
  ILINK.IlinkIcfFile: .\Generated_Source\PSoC5\Cm3Iar.icf
  ILINK.IlinkExtraOptions: .\Export\ARM_IAR_Generic\CyComponentLibrary.a
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: .; Generated_Source\PSoC5
  ICCARM.CCOptLevel: 3
  group FEC2_PSoC_V01_prjct/Documents
    ./: VersionDescription.txt
  group FEC2_PSoC_V01_prjct/Generated_Header
    Generated_Source/PSoC5/: Board_Type_Sel_Reg.h Bridge_current_FB_CH1.h Bridge_current_FB_CH1_aliases.h Bridge_current_FB_CH2.h Bridge_current_FB_CH2_aliases.h Bridge_H_S_out_CH1.h Bridge_H_S_out_CH1_aliases.h Bridge_H_S_out_CH2.h Bridge_H_S_out_CH2_aliases.h Bridge_L_S_out_CH1.h Bridge_L_S_out_CH1_aliases.h Bridge_L_S_out_CH2.h Bridge_L_S_out_CH2_aliases.h Clock_2.h Clock_3.h Clock_4.h Clock_5.h Clock_6.h core_cm3.h core_cm3_psoc5.h core_cmFunc.h core_cmInstr.h CS_DAB_1.h CS_DAB_1_IsCurrent.h CS_DAB_1_Main_DMA_dma.h CS_DAB_1_P_isr.h CS_DAB_1_Peak_DMA_dma.h CS_DAB_1_Store_Peak_DMA_dma.h CS_DAB_1_Store_Zero_DMA_dma.h CS_DAB_1_Z_isr.h CS_DAB_1_Zero_DMA_dma.h CS_DAB_2.h CS_DAB_2_IsCurrent.h CS_DAB_2_Main_DMA_dma.h CS_DAB_2_P_isr.h CS_DAB_2_Peak_DMA_dma.h CS_DAB_2_Store_Peak_DMA_dma.h CS_DAB_2_Store_Zero_DMA_dma.h CS_DAB_2_Z_isr.h CS_DAB_2_Zero_DMA_dma.h Current_Sensor_1.h Current_Sensor_1_aliases.h Current_Sensor_2.h Current_Sensor_2_aliases.h cydevice.h cydevice_trm.h cydevicegnu.inc cydevicegnu_trm.inc cydeviceiar.inc cydeviceiar_trm.inc cydevicerv.inc cydevicerv_trm.inc cydisabledsheets.h CyDmac.h cyfitter.h cyfitter_cfg.h cyfittergnu.inc cyfitteriar.inc cyfitterrv.inc CyFlash.h CyLib.h cypins.h cyPm.h CySpc.h cytypes.h DAC_for_4_20mA_1.h DAC_for_4_20mA_1_aliases.h DAC_for_4_20mA_2.h DAC_for_4_20mA_2_aliases.h Diagnostic_feedback_CH1_2.h Diagnostic_feedback_CH1_2_aliases.h Diagnostic_feedback_CH3_4.h Diagnostic_feedback_CH3_4_aliases.h Digital_input_1.h Digital_input_1_aliases.h Digital_input_2.h Digital_input_2_aliases.h Digital_input_3.h Digital_input_3_aliases.h Digital_input_4.h Digital_input_4_aliases.h Digital_input_5.h Digital_input_5_aliases.h Digital_input_6.h Digital_input_6_aliases.h Digital_out_0_5A_CH1.h Digital_out_0_5A_CH1_aliases.h Digital_out_0_5A_CH2.h Digital_out_0_5A_CH2_aliases.h Digital_out_0_5A_CH3.h Digital_out_0_5A_CH3_aliases.h Digital_out_0_5A_CH4.h Digital_out_0_5A_CH4_aliases.h Direct_PSOC_to_micro_1.h Direct_PSOC_to_micro_1_aliases.h Direct_PSOC_to_micro_2.h Direct_PSOC_to_micro_2_aliases.h DMA_RX_S_dma.h DMA_TX_S_dma.h DOD_Control_Reg.h DOD_DigitalOutputsDriver.h DOD_PrISM.h DOD_PWM_1.h DOD_PWM_2.h DOD_PWM_3.h DOD_PWM_4.h DOD_SPWM.h DOD_SPWM_isr_Load.h DOD_SPWM_ParallelLoad.h DSM.h DSM_Bypass_P32.h DSM_Bypass_P32_aliases.h DSM_DMA_dma.h DSM_Ext_CP_Clk.h DSM_IRQ.h DSM_Sequencer_DSM_Sequencer.h DSM_Sequencer_SOC_Delay.h DSM_theACLK.h Global_input_1.h Global_input_1_aliases.h Global_input_2.h Global_input_2_aliases.h Global_input_3.h Global_input_3_aliases.h Global_input_4.h Global_input_4_aliases.h Global_input_5.h Global_input_5_aliases.h Global_input_6.h Global_input_6_aliases.h GREEN_LED.h GREEN_LED_aliases.h Heat_Counter_isr.h I4_20mA_input_1.h I4_20mA_input_1_aliases.h I4_20mA_input_2.h I4_20mA_input_2_aliases.h IDAC.h Input_connector_ID_1.h Input_connector_ID_1_aliases.h Input_connector_ID_2.h Input_connector_ID_2_aliases.h ISR_DSM_DMA.h isr_LogicFunc.h isr_Safety_Relay.h ISR_SAR1_AnlgIn_DMA.h ISR_SAR2_IDs_DMA.h isr_SPIS_Rx.h isr_Timer.h MainsX2.h OTSM_1.h output_connector_ID.h output_connector_ID_aliases.h project.h PSOC_RX.h PSOC_RX_aliases.h PSOC_TX.h PSOC_TX_aliases.h PT1_ADC_IN_N.h PT1_ADC_IN_N_aliases.h PT1_ADC_IN_P.h PT1_ADC_IN_P_aliases.h PT1_current_out.h PT1_current_out_aliases.h PT2_ADC_IN_N.h PT2_ADC_IN_N_aliases.h PT2_ADC_IN_P.h PT2_ADC_IN_P_aliases.h PT2_current_out.h PT2_current_out_aliases.h PT3_ADC_IN_N.h PT3_ADC_IN_N_aliases.h PT3_ADC_IN_P.h PT3_ADC_IN_P_aliases.h PT3_current_out.h PT3_current_out_aliases.h PT4_ADC_IN_N.h PT4_ADC_IN_N_aliases.h PT4_ADC_IN_P.h PT4_ADC_IN_P_aliases.h PT4_current_out.h PT4_current_out_aliases.h PT_cal_ADC_IN_N.h PT_cal_ADC_IN_N_aliases.h PT_cal_ADC_IN_P.h PT_cal_ADC_IN_P_aliases.h PT_cal_current_out.h PT_cal_current_out_aliases.h RED_LED.h RED_LED_aliases.h RTD.h safety_feedback.h safety_feedback_aliases.h Safety_Relay.h Safety_Relay_aliases.h SAR1.h SAR1_AnlgIn_DMA_dma.h SAR1_Flwr.h SAR1_IRQ.h SAR1_theACLK.h SAR2.h SAR2_Flwr.h SAR2_IDs_DMA_dma.h SAR2_IRQ.h SAR2_theACLK.h SPI_chip_select.h SPI_chip_select_aliases.h SPI_MISO.h SPI_MISO_aliases.h SPI_MOSI.h SPI_MOSI_aliases.h SPI_SCLK.h SPI_SCLK_aliases.h SPIS.h SPIS_IntClock.h SPIS_PVT.h SSR_Thermistor.h SSR_Thermistor_aliases.h System_Control_Reg.h Task_Indctr_VDAC.h Thermistor.h VDAC1.h VDAC1_Flwr.h VDAC2.h VDAC2_Flwr.h ZERO_CROSS_1.h ZERO_CROSS_1_aliases.h ZERO_CROSS_2.h ZERO_CROSS_2_aliases.h ZERO_CROSS_3.h ZERO_CROSS_3_aliases.h
  group FEC2_PSoC_V01_prjct/Generated_Source
    Generated_Source/PSoC5/: Board_Type_Sel_Reg.c Bridge_current_FB_CH1.c Bridge_current_FB_CH2.c Bridge_H_S_out_CH1.c Bridge_H_S_out_CH2.c Bridge_L_S_out_CH1.c Bridge_L_S_out_CH2.c Clock_2.c Clock_3.c Clock_4.c Clock_5.c Clock_6.c Cm3Start.c CS_DAB_1.c CS_DAB_1_IsCurrent.c CS_DAB_1_IsCurrent_PM.c CS_DAB_1_Main_DMA_dma.c CS_DAB_1_P_isr.c CS_DAB_1_Peak_DMA_dma.c CS_DAB_1_Store_Peak_DMA_dma.c CS_DAB_1_Store_Zero_DMA_dma.c CS_DAB_1_Z_isr.c CS_DAB_1_Zero_DMA_dma.c CS_DAB_2.c CS_DAB_2_IsCurrent.c CS_DAB_2_IsCurrent_PM.c CS_DAB_2_Main_DMA_dma.c CS_DAB_2_P_isr.c CS_DAB_2_Peak_DMA_dma.c CS_DAB_2_Store_Peak_DMA_dma.c CS_DAB_2_Store_Zero_DMA_dma.c CS_DAB_2_Z_isr.c CS_DAB_2_Zero_DMA_dma.c Current_Sensor_1.c Current_Sensor_2.c CyBootAsmIar.s CyDmac.c cyfitter_cfg.c CyFlash.c CyLib.c cymetadata.c cyPm.c CySpc.c cyutils.c DAC_for_4_20mA_1.c DAC_for_4_20mA_2.c Diagnostic_feedback_CH1_2.c Diagnostic_feedback_CH3_4.c Digital_input_1.c Digital_input_2.c Digital_input_3.c Digital_input_4.c Digital_input_5.c Digital_input_6.c Digital_out_0_5A_CH1.c Digital_out_0_5A_CH2.c Digital_out_0_5A_CH3.c Digital_out_0_5A_CH4.c Direct_PSOC_to_micro_1.c Direct_PSOC_to_micro_2.c DMA_RX_S_dma.c DMA_TX_S_dma.c DOD_Control_Reg.c DOD_DigitalOutputsDriver.c DOD_PrISM.c DOD_PrISM_PM.c DOD_PWM_1.c DOD_PWM_1_PM.c DOD_PWM_2.c DOD_PWM_2_PM.c DOD_PWM_3.c DOD_PWM_3_PM.c DOD_PWM_4.c DOD_PWM_4_PM.c DOD_SPWM.c DOD_SPWM_isr_Load.c DOD_SPWM_ParallelLoad.c DSM.c DSM_Bypass_P32.c DSM_DMA_dma.c DSM_Ext_CP_Clk.c DSM_INT.c DSM_IRQ.c DSM_PM.c DSM_Sequencer_DSM_Sequencer.c DSM_Sequencer_SOC_Delay.c DSM_Sequencer_SOC_Delay_PM.c DSM_theACLK.c Global_input_1.c Global_input_2.c Global_input_3.c Global_input_4.c Global_input_5.c Global_input_6.c GREEN_LED.c Heat_Counter_isr.c I4_20mA_input_1.c I4_20mA_input_2.c IDAC.c IDAC_PM.c Input_connector_ID_1.c Input_connector_ID_2.c ISR_DSM_DMA.c isr_LogicFunc.c isr_Safety_Relay.c ISR_SAR1_AnlgIn_DMA.c ISR_SAR2_IDs_DMA.c isr_SPIS_Rx.c isr_Timer.c MainsX2.c OTSM_1.c output_connector_ID.c PSOC_RX.c PSOC_TX.c PT1_ADC_IN_N.c PT1_ADC_IN_P.c PT1_current_out.c PT2_ADC_IN_N.c PT2_ADC_IN_P.c PT2_current_out.c PT3_ADC_IN_N.c PT3_ADC_IN_P.c PT3_current_out.c PT4_ADC_IN_N.c PT4_ADC_IN_P.c PT4_current_out.c PT_cal_ADC_IN_N.c PT_cal_ADC_IN_P.c PT_cal_current_out.c RED_LED.c RTD.c safety_feedback.c Safety_Relay.c SAR1.c SAR1_AnlgIn_DMA_dma.c SAR1_Flwr.c SAR1_Flwr_PM.c SAR1_INT.c SAR1_IRQ.c SAR1_PM.c SAR1_theACLK.c SAR2.c SAR2_Flwr.c SAR2_Flwr_PM.c SAR2_IDs_DMA_dma.c SAR2_INT.c SAR2_IRQ.c SAR2_PM.c SAR2_theACLK.c SPI_chip_select.c SPI_MISO.c SPI_MOSI.c SPI_SCLK.c SPIS.c SPIS_BOOT.c SPIS_INT.c SPIS_IntClock.c SPIS_PM.c SSR_Thermistor.c System_Control_Reg.c Task_Indctr_VDAC.c Task_Indctr_VDAC_PM.c Thermistor.c VDAC1.c VDAC1_Flwr.c VDAC1_Flwr_PM.c VDAC1_PM.c VDAC2.c VDAC2_Flwr.c VDAC2_Flwr_PM.c VDAC2_PM.c ZERO_CROSS_1.c ZERO_CROSS_2.c ZERO_CROSS_3.c
  group FEC2_PSoC_V01_prjct/Header
    ../FEC2_PSoC_Common/: Analog_IO_Module_Handler.h Communications_Handler.h device.h Digital_IO_Module_Handler.h DSP.h ICDMessageStructs.h main.h Safety_Module_Handler.h System_Handler.h Temperature_Module_Handler.h version.h
    ./: Monitor_Module_Handler.h
  group FEC2_PSoC_V01_prjct/Source
    ../FEC2_PSoC_Common/: Aanlog_IO_ISRs.c Analog_IO_Module_Handler.c Communications_Handler.c Digital_IO_Module_Handler.c DSP.c Safety_ISRs.c Safety_Module_Handler.c System_Handler.c Temperature_ISRs.c Temperature_Module_Handler.c
    ./: main.c Monitor_ISRs.c Monitor_Module_Handler.c
