<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FEC2_PSoC_Control.ewp</path>
  </project>
  <batchBuild/>
</workspace>


