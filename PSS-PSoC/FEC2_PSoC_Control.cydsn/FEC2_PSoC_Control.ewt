<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>FEC2_PSoC_Control</name>
    <group>
      <name>Generated_Header</name>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_current_FB_CH1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_current_FB_CH1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_current_FB_CH2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_current_FB_CH2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_H_S_out_CH1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_H_S_out_CH1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_H_S_out_CH2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_H_S_out_CH2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_L_S_out_CH1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_L_S_out_CH1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_L_S_out_CH2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_L_S_out_CH2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_6.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\core_cm3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\core_cm3_psoc5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\core_cmFunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\core_cmInstr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_IsCurrent.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Main_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Peak_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Store_Peak_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Store_Zero_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Zero_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Current_Sensor_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Current_Sensor_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Current_Sensor_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Current_Sensor_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydevice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydevice_trm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydevicegnu.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydevicegnu_trm.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydeviceiar.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydeviceiar_trm.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydevicerv.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydevicerv_trm.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cydisabledsheets.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CyDmac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyfitter.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyfitter_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyfittergnu.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyfitteriar.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyfitterrv.inc</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CyFlash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CyLib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cypins.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyPm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CySpc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cytypes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DAC_for_4_20mA_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DAC_for_4_20mA_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DAC_for_4_20mA_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DAC_for_4_20mA_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Debug_Pin.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Debug_Pin_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Diagnostic_feedback_CH1_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Diagnostic_feedback_CH1_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Diagnostic_feedback_CH3_4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Diagnostic_feedback_CH3_4_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_3_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_4_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_5_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_6.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_6_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH3_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH4_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Direct_PSOC_to_micro_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Direct_PSOC_to_micro_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Direct_PSOC_to_micro_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Direct_PSOC_to_micro_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_Control_Reg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_DigitalOutputsDriver.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PrISM.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_SPWM.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_SPWM_isr_Load.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_SPWM_ParallelLoad.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Bypass_P32.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Bypass_P32_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Ext_CP_Clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_IRQ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Sequencer_DSM_Sequencer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Sequencer_SOC_Delay.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_theACLK.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_3_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_4_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_5.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_5_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_6.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_6_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\GREEN_LED.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\GREEN_LED_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\I4_20mA_input_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\I4_20mA_input_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\I4_20mA_input_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\I4_20mA_input_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\IDAC.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Input_connector_ID_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Input_connector_ID_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Input_connector_ID_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Input_connector_ID_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ISR_DSM_DMA.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ISR_SAR1_AnlgIn_DMA.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ISR_SAR2_IDs_DMA.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\isr_Timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\MainsX2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\output_connector_ID.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\output_connector_ID_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\P_isr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\project.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_ADC_IN_N.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_ADC_IN_N_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_ADC_IN_P.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_ADC_IN_P_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_current_out.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_current_out_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_ADC_IN_N.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_ADC_IN_N_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_ADC_IN_P.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_ADC_IN_P_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_current_out.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_current_out_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_ADC_IN_N.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_ADC_IN_N_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_ADC_IN_P.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_ADC_IN_P_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_current_out.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_current_out_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_ADC_IN_N.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_ADC_IN_N_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_ADC_IN_P.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_ADC_IN_P_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_current_out.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_current_out_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_ADC_IN_N.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_ADC_IN_N_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_ADC_IN_P.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_ADC_IN_P_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_current_out.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_current_out_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\RED_LED.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\RED_LED_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\RTD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_AnlgIn_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_Flwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_IRQ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_theACLK.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_Flwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_IDs_DMA_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_IRQ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_theACLK.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SSR_Thermistor.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SSR_Thermistor_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\System_Control_Reg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Task_Indctr_VDAC.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Thermistor.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC1_Flwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC2_Flwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Watch_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Watch_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Watch_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Watch_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Z_isr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_1_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_2_aliases.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_3_aliases.h</name>
      </file>
    </group>
    <group>
      <name>Generated_Source</name>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_current_FB_CH1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_current_FB_CH2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_H_S_out_CH1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_H_S_out_CH2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_L_S_out_CH1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Bridge_L_S_out_CH2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Clock_6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Cm3Start.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_IsCurrent.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_IsCurrent_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Main_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Peak_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Store_Peak_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Store_Zero_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CSAB_1_Zero_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Current_Sensor_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Current_Sensor_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CyBootAsmIar.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CyDmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyfitter_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CyFlash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CyLib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cymetadata.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyPm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\CySpc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\cyutils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DAC_for_4_20mA_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DAC_for_4_20mA_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Debug_Pin.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Diagnostic_feedback_CH1_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Diagnostic_feedback_CH3_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_input_6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Digital_out_0_5A_CH4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Direct_PSOC_to_micro_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Direct_PSOC_to_micro_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_Control_Reg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_DigitalOutputsDriver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PrISM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PrISM_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_1_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_2_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_3_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_PWM_4_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_SPWM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_SPWM_isr_Load.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DOD_SPWM_ParallelLoad.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Bypass_P32.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Ext_CP_Clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_INT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_IRQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Sequencer_DSM_Sequencer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Sequencer_SOC_Delay.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_Sequencer_SOC_Delay_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\DSM_theACLK.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Global_input_6.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\GREEN_LED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\I4_20mA_input_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\I4_20mA_input_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\IDAC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\IDAC_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Input_connector_ID_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Input_connector_ID_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ISR_DSM_DMA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ISR_SAR1_AnlgIn_DMA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ISR_SAR2_IDs_DMA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\isr_Timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\MainsX2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\output_connector_ID.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\P_isr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_ADC_IN_N.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_ADC_IN_P.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT1_current_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_ADC_IN_N.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_ADC_IN_P.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT2_current_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_ADC_IN_N.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_ADC_IN_P.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT3_current_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_ADC_IN_N.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_ADC_IN_P.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT4_current_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_ADC_IN_N.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_ADC_IN_P.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\PT_cal_current_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\RED_LED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\RTD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_AnlgIn_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_Flwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_Flwr_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_INT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_IRQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR1_theACLK.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_Flwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_Flwr_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_IDs_DMA_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_INT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_IRQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SAR2_theACLK.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\SSR_Thermistor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\System_Control_Reg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Task_Indctr_VDAC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Task_Indctr_VDAC_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Thermistor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC1_Flwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC1_Flwr_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC1_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC2_Flwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC2_Flwr_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\VDAC2_PM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Watch_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Watch_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\Z_isr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Source\PSoC5\ZERO_CROSS_3.c</name>
      </file>
    </group>
    <group>
      <name>Header</name>
      <file>
        <name>$PROJ_DIR$\Analog_IO_Module_Handler.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\device.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Digital_IO_Module_Handler.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DSP.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Monitor_Module_Handler.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\System_Handler.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Temperature_Module_Handler.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\version.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\Aanlog_IO_ISRs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Analog_IO_Module_Handler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Digital_IO_Module_Handler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DSP.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Monitor_ISRs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Monitor_Module_Handler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\System_Handler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Temperature_ISRs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Temperature_Module_Handler.c</name>
      </file>
    </group>
  </group>
</project>


