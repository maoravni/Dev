# IAR project FEC_BOOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_OTG_FS; USE_EMBEDDED_PHY; USE_IWDG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\Common\GEN_INC; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\USB\VCP\inc; $PROJ_DIR$..\..\SW\APPLIC\inc; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Libraries\BSP\fec; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\include; $PROJ_DIR$..\..\..\FEC\SW\APPLIC\INC; $PROJ_DIR$..\..\..\NewFec\SW\CNFG\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FEC_BOOT.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f207xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_OTG_FS; USE_EMBEDDED_PHY; USE_IWDG; FEC_BOOTLOADER
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\Common\GEN_INC; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\USB\VCP\inc; $PROJ_DIR$..\..\SW\APPLIC\inc; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Libraries\BSP\fec; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\include; $PROJ_DIR$..\..\..\FEC\SW\APPLIC\INC; $PROJ_DIR$..\..\..\NewFec\SW\CNFG\; $PROJ_DIR$..\..\..\Common\ConfigFiles
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: FEC_BOOT.bin
  group APPLIC/INC
    ../SW/APPLIC/inc/: boot_cnfg.h crc_ccitt.h flash_if.h fsdata.h httpserver.h lwipopts.h main.h netconf.h stm32f2x7_eth_bsp.h stm32f2x7_eth_conf.h stm32f2xx_conf.h stm32f2xx_it.h tftpserver.h
  group APPLIC/SRC
    ../SW/APPLIC/src/: crc_ccitt.c flash_if.c fsdata.c httpserver.c main_boot.c netconf.c stm32f2x7_eth_bsp.c stm32f2xx_it.c system_stm32f2xx.c tftpserver.c
  group BSP
    ../../Common/Libraries/BSP/: board_setup.c dg_in_ctrl.c iwdg.c
  group CMSIS
    ../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group EWARM
    ../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group LwIP/Api
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/Core
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/Core/IPv4
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/Netif
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group STM32F2x7_ETH_Driver
    ../../Common/Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPerif_Driver
    ../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_tim.c
