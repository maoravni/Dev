# IAR project fec.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZC ST STM32F207ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; USE_EMBEDDED_PHY; CPP_FRAMEWORK; FEC_BOARD
  ICCARM.CCIncludePath2: ..\SW\CNFG; ..\SW\TmcServer; ..\..\Common; ..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Common\Libraries\BSP\EEPROM; ..\..\Common\Libraries\STM32_CPAL_Driver\inc; ..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\Common\GEN_INC; ..\..\Common\Libraries\BSP; ..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; ..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; ..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; ..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\inc; //..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; //..\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\HMI; $PROJ_DIR$..\..\..\FEC; $PROJ_DIR$..\..\..\FEC\SW\APPLIC\INC; $PROJ_DIR$..\..\..\Common\DB\INC; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\USB\VCP\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Class\cdc\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Core\inc; $PROJ_DIR$..\..\..\Common\VCP_TERM; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOS_EC\Source\; $PROJ_DIR$..\..\..\Common\CppFramework; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\include\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\portable\IAR\ARM_CM3; $PROJ_DIR$..\..\..\Common\MODBUS; $PROJ_DIR$..\..\..\Common\MODBUS\rtu; $PROJ_DIR$..\..\..\Common\AUX_TERM; $PROJ_DIR$..\..\..\Common\TmcServer; $PROJ_DIR$..\..\..\\FEC\SW\TEST; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\contrib\apps\sntp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\SW\CNFG
  OBJCOPY.OOCOutputFile: fec.srec
  ILINK.IlinkOutputFile: fec.out
  ILINK.IlinkIcfFile: ..\..\EWARM_WS\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
configuration CALIBRATION TEST (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; USE_EMBEDDED_PHY; CPP_FRAMEWORK; FEC_BOARD; _CALIBRATION_TEST_
  ICCARM.CCIncludePath2: ..\SW\CNFG; ..\SW\TmcServer; ..\..\Common; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\BSP\EEPROM; $PROJ_DIR$..\..\..\Common\Libraries\STM32_CPAL_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\GEN_INC; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\inc; //$PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; //..\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\HMI; $PROJ_DIR$..\..\..\FEC\SW\APPLIC\INC; $PROJ_DIR$..\..\..\Common\DB\INC; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\USB\VCP\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Class\cdc\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Core\inc; $PROJ_DIR$..\..\..\Common\VCP_TERM; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOS_EC\Source\; $PROJ_DIR$..\..\..\Common\CppFramework; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\include\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\portable\IAR\ARM_CM3; $PROJ_DIR$..\..\..\Common\MODBUS; $PROJ_DIR$..\..\..\Common\MODBUS\rtu; $PROJ_DIR$..\..\..\Common\AUX_TERM; $PROJ_DIR$..\..\..\Common\TmcServer; $PROJ_DIR$..\..\..\\FEC\SW\TEST
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
configuration ATP_VERSION (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; USE_EMBEDDED_PHY; CPP_FRAMEWORK; FEC_BOARD; _ATP_VERSION_; USE_BOOT
  ICCARM.CCIncludePath2: ..\SW\CNFG; ..\SW\TmcServer; ..\..\Common; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\BSP\EEPROM; $PROJ_DIR$..\..\..\Common\Libraries\STM32_CPAL_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\GEN_INC; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\inc; //$PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; //..\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\HMI; $PROJ_DIR$..\..\..\FEC; $PROJ_DIR$..\..\..\FEC\SW\APPLIC\INC; $PROJ_DIR$..\..\..\Common\DB\INC; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\USB\VCP\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Class\cdc\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Core\inc; $PROJ_DIR$..\..\..\Common\VCP_TERM; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOS_EC\Source\; $PROJ_DIR$..\..\..\Common\CppFramework; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\include\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\portable\IAR\ARM_CM3; $PROJ_DIR$..\..\..\Common\MODBUS; $PROJ_DIR$..\..\..\Common\MODBUS\rtu; $PROJ_DIR$..\..\..\Common\AUX_TERM; $PROJ_DIR$..\..\..\Common\TmcServer; $PROJ_DIR$..\..\..\\FEC\SW\TEST
  OBJCOPY.OOCOutputFile: fec.bin
  ILINK.IlinkIcfFile: C:\Landalabs\Spitfire\Branches_Embedded\FirstPrintFEC\EWARM_WS\stm32f2xx_flash_boot.icf
configuration Debug_BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; USE_EMBEDDED_PHY; CPP_FRAMEWORK; FEC_BOARD; USE_BOOT
  ICCARM.CCIncludePath2: ..\SW\CNFG; ..\SW\TmcServer; ..\..\Common; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\BSP\EEPROM; $PROJ_DIR$..\..\..\Common\Libraries\STM32_CPAL_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\GEN_INC; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\inc; //$PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; //..\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\HMI; $PROJ_DIR$..\..\..\FEC; $PROJ_DIR$..\..\..\FEC\SW\APPLIC\INC; $PROJ_DIR$..\..\..\Common\DB\INC; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\USB\VCP\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Class\cdc\inc; $PROJ_DIR$..\..\..\Common\USB\STM32_USB_Device_Library\Core\inc; $PROJ_DIR$..\..\..\Common\VCP_TERM; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOS_EC\Source\; $PROJ_DIR$..\..\..\Common\CppFramework; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\include\; $PROJ_DIR$..\..\..\Common\3rdParty\FreeRTOSV7.2.0\FreeRTOS\Source\portable\IAR\ARM_CM3; $PROJ_DIR$..\..\..\Common\MODBUS; $PROJ_DIR$..\..\..\Common\MODBUS\rtu; $PROJ_DIR$..\..\..\Common\AUX_TERM; $PROJ_DIR$..\..\..\Common\TmcServer; $PROJ_DIR$..\..\..\\FEC\SW\TEST; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\contrib\apps\sntp
  OBJCOPY.OOCOutputFile: fec_boot.bin
  ILINK.IlinkIcfFile: ..\..\EWARM_WS\stm32f2xx_flash_boot.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  group APPLIC
    ../SW/APPLIC/SRC/: BtcCfgDB.c GnrlCfgDB.c Monitor.c OthersCfgDB.c PWM.c TemperatureCfgDB.c
    ../SW/APPLIC/INC/: BtcCfgDB.h EepromDB_Def.h fec.h GnrlCfgDB.h OthersCfgDB.h Pwm.h TemperatureCfgDB.h
    ../../Common/GEN_INC/: ll_typedef.h
    ../: version.h
  group AUX_TERM
    ../../Common/AUX_TERM/: aux_term.c aux_term.h
  group BSP
    ../../Common/Libraries/BSP/: a2d.c a2d.h board_setup.c Board_Temperature_tmp275.c Board_Temperature_tmp275.h bsp_srvcs.h can.c can.h dac.c dac.h dg_in_ctrl.c dg_in_ctrl.h DigTrimmer_ad5292bruz.c DigTrimmer_ad5292bruz.h eeprom_m24m02_dr.c eeprom_m24m02_dr.h Hw_pwm.c Hw_pwm.h iwdg.c iwdg.h netconf.c opto_out.c opto_out.h rtc.c rtc.h
    ../SW/CNFG/: board_setup.h
    ../SW/BSP/: stm32f2x7_eth_bsp.c tcpecho.c usart_fec.c
  group CMSIS
    ../../Common/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../SW/CMSIS/: stm32f2xx_it.c system_stm32f2xx.c
  group CNFG
    ../SW/CNFG/: aux_trm_cnfg.h cfg_db_if_cnfg.h dg_input_cnfg.h eeprom_cnfg.h FreeRTOSConfig.h iwdg_cnfg.h leds_cnfg.h lwipopts.h main.h mb_cnfg.h opto_out_cnfg.h os_cnfg.h stm32f2xx_conf.h
  group CppFrameWork
    ../../Common/CppFramework/: AirBleedingZone.cpp AirBleedingZone.h AirBlowerZone.cpp AirBlowerZone.h AirInletValve.cpp AirInletValve.h AnalogInputZone.cpp AnalogInputZone.h BaseMiddlewareWrapperZone.cpp BaseMiddlewareWrapperZone.h BaseZone.cpp BaseZone.h Calibration.cpp Calibration.h CBaseConnector.cpp CBaseConnector.h CBtc.cpp CBtc.h CBtcComponents.cpp CBtcComponents.h CBtcConfig.h CBtcDef.h CBtcSensors.cpp CBtcSensors.h CLogger.cpp CLogger.h CTcpConnector.cpp CTcpConnector.h CUdpConnector.cpp CUdpConnector.h DigitalInputDevice.cpp DigitalInputDevice.h EventData.cpp EventData.h FanZone.cpp FanZone.h HeaterBase.cpp HeaterBase.h HeaterInternalPid.cpp HeaterInternalPid.h HeaterOutputSetpoint.cpp HeaterOutputSetpoint.h HeaterPumaZone.cpp HeaterPumaZone.h HeaterZone.cpp HeaterZone.h HeatExchangePumaZone.cpp HeatExchangePumaZone.h HeatExchangeZone.cpp HeatExchangeZone.h HumidityZone.cpp HumidityZone.h logger.h MiddlewareRegisterMonitor.cpp MiddlewareRegisterMonitor.h MwAccessor.cpp MwAccessor.h operatorNew.cpp PeriodicMonitorTask.cpp PeriodicMonitorTask.h PID.cpp PID.h PID_AutoTune_v0.cpp PID_AutoTune_v0.h PressureSensorDevice.cpp PressureSensorDevice.h StateMachine.cpp StateMachine.h StatusLed.cpp StatusLed.h TemperatureZone.cpp TemperatureZone.h ZoneManager.cpp ZoneManager.h
  group DB
    ../../Common/DB/SRC/: cfg_db_eeprom.c cfg_db_if.c CfgDB.c CfgDButil.c
    ../../Common/DB/INC/: cfg_db_eeprom.h cfg_db_if.h CfgDB.h CfgDBUtil.h
  group EWARM
    ./: stm32f2xx_flash.icf
  group FreeRTOS
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Include
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/Memmange
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeRTOS/portable
    ../../Common/3rdParty/FreeRTOSV7.2.0/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOS_EC
    ../../Common/3rdParty/FreeRTOS_EC/Source/: AManagedTask.cpp AManagedTask.h ASyncObject.cpp ASyncObject.h ATimer.cpp ATimer.h CBinarySemaphore.cpp CBinarySemaphore.h CCountingSemaphore.cpp CCountingSemaphore.h CFreeRTOS.cpp CFreeRTOS.h CMessageTask.cpp CMessageTask.h CMutex.cpp CMutex.h CQueue.cpp CQueue.h CRecursiveMutex.cpp CRecursiveMutex.h CSharedResource.h CTask.cpp CTask.h IFreeRTOSProtocol.h IMessageTaskDelegate.h Message.h MessageMacro.h
  group HMI
    ../../Common/HMI/: leds.c leds.h
  group LWIP/API
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/CORE
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LWIP/CORE/IPv4
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP/NETIF
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group LWIP/SNTP
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/contrib/apps/sntp/: sntp.c sntp.h
  group MAIN
    ../SW/MAIN/: Main.cpp
  group MODBUS/COMMON
    ../../Common/MODBUS/Common/: mb_infra.c mb_infra.h
  group MODBUS/RTU
    ../../Common/MODBUS/Rtu/: rtu_master.c rtu_master.h rtu_msgs.h rtu_slave.c rtu_slave.h
  group MODBUS/TCP_MB
    ../../Common/MODBUS/MbTcp/: tcp_mb.c tcp_mb.h
  group STM32F2x7_ETH_Driver
    ../../Common/Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group TEST
    ../SW/TEST/: a2d_tst.c a2d_tst.h can_tst.c can_tst.h dig_in_tst.c dig_in_tst.h e2_tst.c e2_tst.h main.c mod_bus_tst.c mod_bus_tst.h test_board.c test_board.h
  group TmcServer
    ../../Common/TmcServer/: BtcZoneManager.cpp BtcZoneManager.h DryerZoneManager.cpp DryerZoneManager.h FecZones.cpp FecZones.h GeneratedMessages.def.h GeneratedMessages.msg.h IbdZoneManager.cpp IbdZoneManager.h IthZoneManager.cpp IthZoneManager.h MessageStructs.h TmcMasterServer.cpp TmcMasterServer.h TmcMessageHandler.cpp TmcMessageHandler.h TmcStateMachine.cpp TmcStateMachine.h
  group TmcServer/MessageCreator
    ../../Common/TmcServer/MessageCreator/: GeneratedMessages.def.h GeneratedMessages.msg.h
  group Trace
    ../../Common/DebugTrace/: LogSys.c
  group USB/STM32_USB_Device_Library/Class/cdc
    ../../Common/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../../Common/USB/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h
  group USB/STM32_USB_Device_Library/Core
    ../../Common/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Common/USB/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USB/STM32_USB_OTG_Driver
    ../../Common/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB/VCP
    ../../Common/USB/VCP/src/: data.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group VCP_TERM
    ../../Common/VCP_TERM/: vcp_term.c vcp_term.h
