# IAR project Mosquito.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\SW\APPLIC\INC; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\FreeRTOS_v6.1.0\include; ..\Common\HMI; ..\SW\CNFG; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\STM32_USB_OTG_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\STM32_USB_Device_Library\Core\inc; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\STM32_USB_Device_Library\Class\cdc\inc; $PROJ_DIR$..\..\SW\BSP\USB_BSP; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\STM32_USB_Device_Library\Core\inc; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\STM32_USB_Device_Library\Class\cdc\inc; $PROJ_DIR$..\..\..\Common\GEN_INC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\SW\CNFG
  ILINK.IlinkOutputFile: Mosquito.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\FreeRTOS_v6.1.0\include; ..\Common\HMI; ..\SW\CNFG
  ICCARM.CCOptLevel: 3
  group APPLIC/INC
    ../SW/APPLIC/INC/: CmdHnd.h ll_typedef.h
    ../SW/CNFG/: os_cnfg.h
  group APPLIC/SRC
    ../SW/APPLIC/SRC/: CmdHnd.c
  group AUX_TERM
    ../../Common/AUX_TERM/: aux_term.c aux_term.h
  group BSP
    ../SW/BSP/: board_setup.c bsp_srvcs.h ssr.c Timers.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ../SW/CNFG/: board_setup.h
    ../../Common/Libraries/BSP/: usart.c usart.h
  group CMSIS
    ../SW/CMSIS/: stm32f2xx_it.c system_stm32f2xx.c
  group CNFG
    ../SW/CNFG/: aux_trm_cnfg.h FreeRTOSConfig.h leds_cnfg.h mb_cnfg.h stm32f2xx_conf.h usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h
  group EWARM
    ./: startup_stm32f2xx.s
  group FreeRTOS
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/: croutine.c list.c queue.c tasks.c
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/include/: free_rtos_exp.h
  group FreeRTOS/portable
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/portable/MemMang/: heap_2.c
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/portable/EWARM/ARM_CM3/: port.c portasm.s
  group HMI
    ../../Common/HMI/: hmi.h leds.c leds.h
  group MODBUS/Common
    ../../Common/MODBUS/Common/: mb_infra.c mb_infra.h
  group MODBUS/RTU
    ../../Common/MODBUS/Rtu/: rtu_master.c rtu_master.h rtu_msgs.h rtu_slave.c rtu_slave.h
  group STM32F2xx_StdPeriph_Driver
    ../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group TEST
    ../SW/TEST/: main_test.c
  group USB/DRV
    ../../Common/Utilities/Third_Party/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB/DVC/CLASS/CDC
    ../../Common/Utilities/Third_Party/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB/DVC/LIB
    ../../Common/Utilities/Third_Party/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
