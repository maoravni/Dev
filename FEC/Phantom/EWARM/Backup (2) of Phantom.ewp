# IAR project Backup (2) of Phantom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\FreeRTOS_v6.1.0\include; ..\SW\CNFG; $PROJ_DIR$..\..\..\Common\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2xx_StdPeriph_Driver\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\GEN_INC; $PROJ_DIR$..\..\..\Common\Libraries\BSP; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\inc; //$PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; //..\inc; $PROJ_DIR$..\..\..\Common\Libraries\STM32F2x7_ETH_Driver\inc; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\Common; $PROJ_DIR$..\..\..\Common\Utilities\STM32_EVAL\STM322xG_EVAL; $PROJ_DIR$..\..\..\Common\Utilities\Third_Party\lwip_v1.3.2\src\include\; $PROJ_DIR$..\..\..\Common\HMI; $PROJ_DIR$..\..\..\Phantom\SW\APPLIC\INC; $PROJ_DIR$..\..\..\Common\DB\INC; $PROJ_DIR$..\..\..\TraceRecorderSrc\Include; $PROJ_DIR$..\..\..\TraceRecorderSrc\Configuration
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\SW\CNFG
  OBJCOPY.OOCOutputFile: Phantom.srec
  ILINK.IlinkOutputFile: Phantom.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APPLIC
    ../SW/APPLIC/SRC/: CmbrCfgDB.c GnrlCfgDB.c Monitor.c PWM.c
    ../SW/APPLIC/INC/: CmbrCfgDB.h GnrlCfgDB.h Phantom.h
    ../../Common/GEN_INC/: ll_typedef.h
  group AUX_TERM
    ../../Common/AUX_TERM/: aux_term.c aux_term.h
  group BSP
    ../../Common/Libraries/BSP/: board_setup.c bsp_srvcs.h iwdg.c iwdg.h rtc.c rtc.h
    ../SW/CNFG/: board_setup.h
    ../SW/BSP/: netconf.c stm32f2x7_eth_bsp.c tcpecho.c usart_ph.c
  group CMSIS
    ../SW/CMSIS/: stm32f2xx_it.c system_stm32f2xx.c
  group CNFG
    ../SW/CNFG/: aux_trm_cnfg.h cfg_db_if_cnfg.h FreeRTOSConfig.h iwdg_cnfg.h leds_cnfg.h lwipopts.h main.h mb_cnfg.h os_cnfg.h stm32f2xx_conf.h
  group DB
    ../../Common/DB/SRC/: cfg_db_if.c CfgDB.c CfgDButil.c
    ../../Common/DB/INC/: cfg_db_if.h CfgDB.h cfgDBUtil.h
  group EWARM
    ./: startup_stm32f2xx.s
  group FreeRTOS
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/: croutine.c list.c queue.c tasks.c
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/include/: free_rtos_exp.h
  group FreeRTOS/portable
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/portable/MemMang/: heap_2.c
    ../../Common/Utilities/Third_Party/FreeRTOS_v6.1.0/portable/EWARM/ARM_CM3/: port.c portasm.s
  group HMI
    ../../Common/HMI/: leds.c leds.h
  group LWIP/API
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/CORE
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LWIP/CORE/IPv4
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP/NETIF
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Common/Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group MODBUS/COMMON
    ../../Common/MODBUS/Common/: mb_infra.c mb_infra.h
  group MODBUS/RTU
    ../../Common/MODBUS/Rtu/: rtu_master.c rtu_master.h rtu_msgs.h rtu_slave.c rtu_slave.h
  group MODBUS/TCP_MB
    ../../Common/MODBUS/MbTcp/: tcp_mb.c tcp_mb.h
  group STM32F2x7_ETH_Driver
    ../../Common/Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../../Common/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
    ../../Common/Libraries/STM32F2xx_StdPeriph_Driver/inc/: stm32f2xx_pwr.h stm32f2xx_rtc.h
  group TEST
    ../SW/TEST/: main_test.c
  group TraceDebug/INC
    ../../Common/GEN_INC/: LogSys.h
  group TraceDebug/SRC
    ../../Common/DebugTrace/: LogSys.c
