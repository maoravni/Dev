<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FEC2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\FEC2_BOOT\FEC2BootloaderDebug.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\FEC2Release.ewp</path>
  </project>
  <batchBuild/>
</workspace>


